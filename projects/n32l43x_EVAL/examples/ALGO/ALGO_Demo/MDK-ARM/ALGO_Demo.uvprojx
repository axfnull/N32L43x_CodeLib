# Keil uVision project ALGO_Demo.uvprojx, settings and files
target N32L43x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32L436MB Nationstech
  pack: Nationstech.N32L43x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ALGO_Demo +hex
  AfterMake: fromelf.exe --bin .\Objects\ALGO_Demo.axf --output=.\Objects\ALGO_Demo.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L43X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\N32L43x_std_periph_driver\inc;..\..\..\..\bsp\inc;..\..\..\..\..\..\firmware\N32L43x_algo_lib\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l43x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l43x.c
  group FWLB
    ../../../../../../firmware/n32l43x_std_periph_driver/src/: misc.c n32l43x_gpio.c n32l43x_rcc.c n32l43x_usart.c n32l43x_flash.c
  group USER
    ../src/: main.c n32l43x_it.c
  group BSP
    ../../../../bsp/src/: log.c
  group ALGO
    ../../../../../../firmware/n32l43x_algo_lib/lib/: n32l43x_aes.lib n32l43x_algo_common.lib n32l43x_des.lib n32l43x_hash.lib n32l43x_rng.lib
