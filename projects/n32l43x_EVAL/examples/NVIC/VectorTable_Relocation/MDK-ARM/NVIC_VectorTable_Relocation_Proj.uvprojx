# Keil uVision project NVIC_VectorTable_Relocation_Proj.uvprojx, settings and files
target N32L43x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32L436RB Nationstech
  pack: Nationstech.N32L43x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: NVIC_VectorTable_Relocation_Proj +hex
  AfterMake: fromelf --bin --output=.\bin\NVIC_VectorTable_Relocation_Proj.bin .\Objects\NVIC_VectorTable_Relocation_Proj.axf
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L43X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32l43x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l43x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l43x.c
  group FWLB
    ../../../../../../firmware/n32l43x_std_periph_driver/src/: misc.c n32l43x_exti.c n32l43x_gpio.c n32l43x_rcc.c n32l43x_tim.c n32l43x_usart.c
  group BSP
    ../../../../bsp/src/: log.c
  group USER
    ../src/: main.c n32l43x_it.c
  group DOC
    ../: readme.txt
target N32L43x_SRAM (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: N32L436RB Nationstech
  pack: Nationstech.N32L43x_DFP.0.1.0
  cpu: as above
  output: NVIC_VectorTable_Relocation_Proj +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: N32L43X, USE_STDPERIPH_DRIVER, VECT_TAB_SRAM
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x20004000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x4000
