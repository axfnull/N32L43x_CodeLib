# Keil uVision project RotationCount.uvprojx, settings and files
target N32L43x (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32L436MB Nationstech
  pack: Nationstech.N32L43x_DFP.0.1.0
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Rotation +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32L43X, USE_STDPERIPH_DRIVER
  c include: ..\inc;..\..\..\..\..\..\firmware\CMSIS\core;..\..\..\..\..\..\firmware\CMSIS\device;..\..\..\..\..\..\firmware\n32l43x_std_periph_driver\inc;..\..\..\..\bsp\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group STARTUP
    ../../../../../../firmware/CMSIS/device/startup/: startup_n32l43x.s
  group CMSIS
    ../../../../../../firmware/CMSIS/device/: system_n32l43x.c
  group USER
    ../src/: main.c delay.c n32l43x_it.c
  group FWLB
    ../../../../../../firmware/n32l43x_std_periph_driver/src/: n32l43x_comp.c n32l43x_exti.c n32l43x_flash.c n32l43x_gpio.c n32l43x_lprcnt.c n32l43x_pwr.c n32l43x_rcc.c n32l43x_usart.c misc.c
  group LOG
    ../../../../bsp/src/: log.c
  group DOC
    ../: readme.txt
